# See balena documentation
# TODO:  kernel-balena does not exist?
# inherit kernel-balena
inherit kernel-resin
