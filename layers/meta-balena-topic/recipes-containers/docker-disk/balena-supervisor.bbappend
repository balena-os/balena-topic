# TODO

# LED_FILE_tdkzu6 = "/sys/class/leds/led0/brightness"
